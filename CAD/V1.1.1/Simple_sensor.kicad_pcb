# Repository SolderedElectronics/Simple-fire-sensor-board-hardware-design

File README.md:

# Simple fire sensor board Hardware Design

## About the Product

|  |
| :----------------------------------------------------------: |
| [Buy Simple fire sensor board](https://www.solde.red/333047) |

This module is a phototransistor that is capable of detecting infrared radiation. Since fire radiates a large number of infrared rays, this sensor will detect them, but this is not its only application. Wherever there are infrared waves, the sensor will detect them (including those from the sun). Using the built-in comparator on its outputs gives either digital (HIGH / LOW) or analog (0V-5V) signals, depending on the intensity of the IR radiation.

---

## Repository Contents

This repository contains all design files for Simple fire sensor board, organized as follows:

- **`CAD` folder**: Contains KiCAD design files, including:
  - Schematics
  - PCB layout
  - Panel PCB layout
  - Source 3D files in Fusion360, if any
  - All files are sorted by version with a detailed change log.
- **`OUTPUTS` folder**: Includes all production-ready files, such as:
  - Bill of Materials (BOM) and interactive BOM (iBOM)
  - PDF versions of schematics
  - 3D `.step` file of the board
  - 3D-printable models
  - Gerber files for PCB manufacturing
  - Image of the pinout of the board
  - Product image
  - Compliance, legal and generic sales documents

Refer to the `Change Log` in the CAD folder for details about updates between versions.

---

## Learn More About the Product

Beyond the repository, explore the following resources:

### Soldered Verify

The **Soldered Verify** system ensures every board you purchase from Soldered is fully functional. It also provides access to exclusive test data for your product. To get started, find the unique Soldered Verify ID on your product's packaging and enter the ID on the [Soldered Verify page](https://soldered.com/verify/) to access test results and additional product details.

### Soldered Community

Soldered Community is your go-to place for technical support. Our engineers track and answer all questions posted there, and it’s a great space for the maker community. Get answers to your questions and solutions for your challenges at [Soldered Community](https://soldered.com/community).

### solde.red

solde.red is an ultimate URL shortener and information hub. Access it by typing solde.red/ followed by your product SKU, e.g., [solde.red/333000](https://solde.red/333000), to find getting-started guides, datasheets, open-source hardware and software files, certifications, images, pinouts, and more. Read more about the shortener [here](https://solde.red/info/).

---

## Contributing

Contributions are welcome! Here’s how you can get involved:

- Submit pull requests to enhance the design or fix issues.
- Report bugs or problems by opening an issue.

We encourage community collaboration to make this product even better.

---

## About Soldered

[Soldered for Makers](https://soldered.com) specializes in designing and manufacturing electronic products tailored for enthusiasts, ranging from hobbyists to professionals. Our portfolio includes electronic boards, sensors, and actuators that are widely utilized in fields such as microelectronics, mechatronics, robotics, programming, and IoT. Every product we offer is designed in-house and built upon open-source hardware and software platforms. Proudly certified and manufactured within the European Union, our catalog likely includes the product you need for your project.

We complement these products with comprehensive tutorials and manuals, product descriptions, schematics, programming codes, and project examples. Our round-the-clock [customer and technical support](https://soldered.com/community) is available for all our products, irrespective of the sales channel. Soldered’s success and services reflect our maker community’s unwavering [trust](https://www.trustpilot.com/review/soldered.com), for which we are deeply grateful. Join our community and create using Soldered products.

---

## License

All Soldered open-source hardware (OSH) is under The TAPR Open Hardware License. Read more in the LICENSE file located in this repository.

**Disclaimer:**

No warranty - all designs in this repository are distributed in the hope that they will be useful, but without any warranty. They are provided "AS IS", therefore without warranty of any kind, either expressed or implied. The entire quality and performance of what you do with the contents of this repository are your responsibility. In no event Soldered Electronics will be liable for your damages, or losses, including any general, special, incidental, or consequential damage arising out of the use or inability to use the contents of this repository. 

---

## Have fun!

Thank you for your support from your fellow makers at Soldered Electronics.

Happy Making!

## KiCad design CAD/V1.1.1/Simple_sensor.kicad_pcb

Parts:
C1, C2: 100n; 0603C
D1: purple; 0402LED
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2: HOLE_3.2mm
K1: HEADER_MALE_2X1
K2: HEADER_MALE_4X1
K3: JST-SH_2pin_1mm_C145954
R1, R2: 10k; 0603R
R3: 2k2; 0402R
R4: tc33x-2-103e
U1: LM393; SOIC−8

Connections:
5V: C2.2, K2.4, R1.2, R2.2, R4.1, U1.8 (VCC)
A0: C1.2, K1.2, K2.2, K3.1, R1.1, U1.3 (1_IN+)
D0: K2.3, R2.1, R3.1, U1.1 (1_OUT)
GND: C1.1, C2.1, D1.2 (K), K1.1, K2.1, K3.2, R4.3, U1.4 (GND)
unnamed: D1.1 (A), R3.2
POT: R4.2, U1.2 (1_IN-)

Notes on the sheet:
HEADER
LM393
INPUT

Board: 2 copper layers, 22.0 x 22.0 mm, 14 parts (2 on the bottom side), 6 nets.

## Commit log

2022-08-06 Updating open source files.
